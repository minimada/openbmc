IMAGE_INSTALL_append = " dhcpcd \
                         phosphor-ipmi-fru \
                       "
