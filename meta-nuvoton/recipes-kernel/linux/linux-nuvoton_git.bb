#KBRANCH ?= "dev-5.10"
#LINUX_VERSION ?= "5.10.23"
KBRANCH ?= "NPCM-5.10-OpenBMC"
LINUX_VERSION ?= "5.10.67"

#SRCREV="395847787d8f955f03bcb350ed9f852346fcda4d"
SRCREV="9ecbd27ae90c936dd828ed148c94313bcb4e2073"

require linux-nuvoton.inc
